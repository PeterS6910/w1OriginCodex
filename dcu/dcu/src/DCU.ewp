# IAR project DCU.ewp, settings and files
configuration R_Bootloader_LON-16-48 (ARM)
  General.OGChipSelectEditMenu: LPC1225 NXP LPC1225
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOOTLOADER; BOOTLOADER16; RELEASE; LON; LOCKED
  ICCARM.IExtraOptions: --diag_suppress=Pe815; --diag_suppress=Pe191; --diag_suppress=Pa082
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BOOTLOADER16
  OBJCOPY.OOCOutputFile: DCU.hex
  prebuild: "VersionIncrementer.exe" "boot_version.h"
  postbuild: "Filepacker\FilePackerTool.exe" /t DCU /va "app_version.h" /s "R_Application_LON-16-48\Exe\dcu.bin" /f "R_Bootloader_LON-16-48\DCU.gz"
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkKeepSymbols: application
  ILINK.IlinkIcfFile: LPC1225_Flash_BootLoader16.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration R_Application_LON-16-48 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE; LON; DEBUG_GENERATOR
  OBJCOPY.OOCOutputFile: DCU.bin
  prebuild: "VersionIncrementer.exe" "app_version.h"
  postbuild: "UpgradeFileChecksum.exe" "R_Application_LON-16-48\Exe\dcu.bin"
  ILINK.IlinkIcfFile: LPC1225_Flash_Application16.icf
configuration D_Application_LON (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; LON; DEBUG_GENERATOR
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: LPC1225_Flash.icf
configuration D_Bootloader_LON (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOOTLOADER; BOOTLOADER16; LON
  OBJCOPY.OOCOutputFile: DCU.bin
configuration D_Application_RS485 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; DEBUG_GENERATOR; RS485
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: LPC1225_Flash.icf
configuration R_Bootloader_LON-16-48_XPRESSO (ARM)
  as the first configuration, except:
  postbuild: "Filepacker\FilePackerTool.exe" /t DCU /va "app_version.h" /s "..\R_Application_LON-16-48\DCU-Lon.bin" /f "R_Bootloader_LON-16-48_XPRESSO\DCU.gz"
  group (top)
    ./: app_version.h boot_version.h changelog.txt core_cm0.c core_cm0.h cstartup_M.s Flash.mac jumpsAsm.s LPC1225_Flash.icf LPC1225_Flash_Application.icf LPC1225_Flash_Application16.icf LPC1225_Flash_BootLoader.icf LPC1225_Flash_BootLoader16.icf LPC1225_Ram.icf main.c
  group CardReaders
    CardReaders/: CardReader.c CardReader.h CrCommunicator.c CrCommunicator.h CrProtocol.c CrProtocol.h CrQueue.c CrQueue.h
  group Communication
    Communication/: clspGeneric.c ClspGeneric.h communication.c communication.h
  group Communication/Clsp485
    Communication/Clsp485/: clsp485.c clsp485.h
  group Communication/ClspLon
    Communication/ClspLon/: ClspAPI.c ClspAPI.h LonBegin.h LonControl.c LonControl.h LonCpTypes.h LonEnd.h LonNvTypes.h LonPlatform.h ShortStackApi.c ShortStackApi.h ShortStackDev.c ShortStackDev.h ShortStackHandlers.c ShortStackInternal.c ShortStackTypes.h
  group Communication/ClspLon/Driver
    Communication/ClspLon/Driver/: LdvSci.c LdvSci.h
  group Communication/ClspLon/Others
    Communication/ClspLon/Others/: Processor.c Processor.h
  group Crypto
    Crypto/: cryptoaes.c cryptoaes.h hashes.c hashes.h
  group DSM
    DSM/: dsm.c dsm.h dsmConfig.c dsmConfig.h dsmStructures.h
  group Flashloader
    Flashloader/: flashloader.c flashloader.h
  group IO
    IO/: DIPSwitch.c DIPSwitch.h InputLeds.c InputLeds.h Inputs.c Inputs.h InputsEnums.h IOExpansion.c IOExpansion.h Outputs.c Outputs.h
  group Maintenance
    Maintenance/: testMode.c testMode.h
  group Notify
    Notify/: crNotify.c crNotify.h
  group System
    System/: baseTypes.c baseTypes.h constants.h dmHandler.c dmHandler.h flashStorage.c flashStorage.h lpc122x.h resultCodes.h StartApplication.s systemInfo.c systemInfo.h Tasks.c Tasks.h watchdog.c watchdog.h
  group System/ADC
    System/ADC/: adc.c adc.h
  group System/Core
    System/Core/: exceptionHandling.c exceptionHandling.h ipr.h system_LPC122x.c system_LPC122x.h
  group System/GPIO
    System/GPIO/: gpio.c gpio.h
  group System/I2C
    System/I2C/: i2c.c i2c.h
  group System/IAP
    System/IAP/: iap.c iap.h
  group System/Timer
    System/Timer/: sysTick.c sysTick.h timer.h timer16.c timer16.h timer32.c timer32.h
  group System/UART
    System/UART/: uart.c uart.h
  group Testing
    Testing/: testing.c testing.h
